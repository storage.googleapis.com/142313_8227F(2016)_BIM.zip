Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-07-11T18:17:40
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jul 11 18:17:40 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{30BDFB82-9BD6-4789-9A5A-FFB1F4FB3A70}\ifc * Database version: 5507 * Database creation date: Thu Jul 11 18:17:39 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jul 11 18:17:39 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jul 11 18:17:39 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 8227F Kitchen faucet with dishwasher valve, 230/12 V, 8227F(2016):8227F Kitchen faucet with dishwasher valve, 230/12 V:386978
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 262.393 mm; FaucetNominalHeight: 316.45 mm; FaucetNominalWidth: 335.509 mm; HandShowerNominalDepth: 73.9526 mm; HandShowerNominalHeight: 210.428 mm; HandShowerNominalWidth: 64 mm; InletConnectionSize: 10 mm
Type - Electrical(Type) - Battery: CR 2450 3 V; Electrical Connection: 230 / 12 V; Operating Voltage: 12 V
Type - General(Type) - Author: Convergo AB; BIMObjectName: 8227F(2016); ConvergoRefNr: 0087-1909-0011-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_45; Uniclass2015Description: Sink manual water supply sets; Uniclass2015Reference: Pr_40_20_87_82; Version: 1; VersionDate: 04/07/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150081767; EMC Directive: 2014/30/EU; EN Standard: EN 817; LVI Number: 6219138; Noise Class: I (ISO 3822) Oras lab.; NRF Number: 4200433; Protection Class: IP 55; RSK Number: 8335466; VVS Number: 705679504
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/8227F; Catalog Drawing URL: http://static.oras.com/catdrw/8227F; Class: Two-handle, plug transformer; Dimension Drawing URL: http://static.oras.com/dimdrw/8227F; FDV Document URL: http://www.oras.com/datasheet/8227F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/8227F; Group: Kitchen faucets; Long Marketing: Kitchen faucet with dishwasher valve, swivel spout, Smart press pad, Smart hand shower and aerator. Spout’s swing angle is factory preset at 110°, can be limited to 60° or 85°. Smart, remote press pad opens water, pushing again closes water, safety stop after 60 seconds. Equipped with an on/off and flow rate control, and a temperature control. Red LED light illuminates the temperature control lever to indicate hot water. The dishwasher valve is opened by pressing the Smart, remote press pad and signal light shows that dishwasher valve is activated. The valve closes automatically after preset period: 4 or 12 hours (one push opens the valve for 4 hours, pushing for 5 seconds opens the valve for 12 hours). Function of the Smart, remote hand shower: when lifting hand shower from the holder water starts to flow from the faucet; by pressing the trigger water comes from the hand shower. Electrical connection with a plug transformer 230/12 V Design: Mario Trimarchi F = with flexible pipes; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;POL;RUS;EST;LTU;LVA;UKR; Model: 8227F Kitchen faucet, 230/12 V; Name_en: 8227F Kitchen faucet, 230/12 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 574 x 348 x 130; Package Weight: 7.8 kg; Product Code: 8227F; Product Datasheet: http://www.oras.com/datasheet/8227F/en; Product Family: ALESSI Swan By Oras; Product Image URL: http://static.oras.com/image/8227F; Product URL: http://static.oras.com/8227F; Type Name: 8227F Kitchen faucet with dishwasher valve, 230/12 V
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: 3S-Installation; Connection: Flexible Inlet Pipes; Connection Size: G3/8; Dishwasher Valve: Smart dishwasher valve; Dishwasher Valve Open Period: 4 h / 12 h; Flow Rate At 300kPa: 0.00600349 m3/s; Installation and Maintenance: http://static.oras.com/manual/8227F; Installation Type: Deck mounted; Lever Handle: Two Operating Lever; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 60; Mounting Holes: 2 Mounting Holes; Pressure Loss With Flow 01ls: 105000 Pa; Spare Parts: http://static.oras.com/sp/8227F; Spout Swivel Range: 110° (85° / 60°); Spout Type: Swivel spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 8227F(2016); Features: Two-handle, plug transformer; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 8227F; Name: 8227F Kitchen faucet, 230/12 V; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:335x260x315 mm / Hand shower: 65x75x210 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 8227F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 8227F Kitchen faucet with dishwasher valve, 230/12 V
Constraints - DefaultElevation: 900 mm; DistanceX-Axis: 200 mm; DistanceY-Axis: 100 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.312103 m2; Volume: 0.0288594 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 8227F(2016): 8227F Kitchen faucet with dishwasher valve, 230/12 V; Family and Type: 8227F(2016): 8227F Kitchen faucet with dishwasher valve, 230/12 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 8227F(2016): 8227F Kitchen faucet with dishwasher valve, 230/12 V; Type Id: 8227F(2016): 8227F Kitchen faucet with dishwasher valve, 230/12 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
